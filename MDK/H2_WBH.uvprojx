# Keil uVision project H2_WBH.uvprojx, settings and files
target PROJECT (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.2
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: H2_WBH +hex
  AfterMake: fromelf --bin --output=.\bin\H2_WBH.bin .\Objects\H2_WBH.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\FWLIB\inc;..\USER\APP\inc;..\USER\CFG\inc;..\USER\HAL\inc;..\USER\inc;..\USER\Device\inc;..\USER\Utils\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group SPL
    ../FWLIB/src/: cw32l010_adc.c cw32l010_atim.c cw32l010_btim.c cw32l010_crc.c cw32l010_debug.c cw32l010_digitalsign.c cw32l010_flash.c cw32l010_gpio.c cw32l010_gtim.c cw32l010_i2c.c cw32l010_iwdt.c cw32l010_lptim.c cw32l010_lvd.c cw32l010_pwr.c cw32l010_ram.c cw32l010_rtc.c cw32l010_spi.c cw32l010_sysctrl.c cw32l010_systick.c cw32l010_uart.c cw32l010_vc.c i2c_eeprom.c system_cw32l010.c
    ../FWLIB/: startup_cw32l010.s
  group HAL
    ../USER/HAL/src/: hal_adc.c hal_gpio.c hal_uart.c hal_tim.c
  group Utils
    ../USER/Utils/src/: utils_queue.c
  group Device
    ../USER/Device/src/: dev_fan.c dev_ir.c dev_led.c
  group APP_CFG
    ../USER/CFG/src/: adc_cfg.c iwdg_cfg.c tim_cfg.c uart_cfg.c led_cfg.c ir_cfg.c fan_cfg.c
  group APP_Task
    ../USER/APP/src/: base_state.c base_dust_mode.c base_self_det.c base_event.c func_ir_decoder.c func_pole_decoder.c func_docking_guide.c func_dust_collect.c func_ir_ack.c
  group APP_Main
    ../USER/src/: main.c
software components: CMSIS:CORE 5.6.0
